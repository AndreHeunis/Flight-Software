# Keil uVision project CubeComputer.uvproj, settings and files
target CubeComputer (ARM-ADS)
  device: EFM32GG280F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: CubeComputer
  c flags: Optim=1
  c define: EFM32GG280F1024 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\libraries\CMSIS\Include;..\..\libraries\Device\EnergyMicro\EFM32GG\Include;..\..\libraries\Device\EnergyMicro\EFM32GG\Include;..\..\libraries\emlib\inc;..\..\libraries\bspLib\inc;..\..\libraries\flashLib;..\..\libraries\flashLib\device;..\..\libraries\flashLib\asp;..\..\libraries\flashLib\trace;..\..\libraries\fatfs\inc
  asm include: ..\;..\..\libraries\CMSIS\Include;..\..\libraries\Device\EnergyMicro\EFM32GG\Include;..\..\libraries\Device\EnergyMicro\EFM32GG\Include;..\..\libraries\bspLib\inc;..\..\libraries\flashLib;..\..\libraries\flashLib\device;..\..\libraries\flashLib\asp;..\..\libraries\flashLib\trace;..\..\libraries\fatfs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\obj\CubeComputer.sct
  group Startup
    ../../libraries/Device/EnergyMicro/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../libraries/Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../libraries/bspLib/src/: bsp_acmp.c bsp_adc.c bsp_dma.c bsp_ebi.c bsp_i2c.c bsp_rtc.c bsp_uart.c bsp_wdg.c
  group EMLib
    ../../libraries/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group FlashLib
    ../../libraries/flashLib/: lld.c
  group FatFS
    ../../libraries/fatfs/src/: diskio.c ff.c microsd.c
  group Source
    ../: main.c tests.c
